# Keil uVision project UCOS-1.uvprojx, settings and files
target UCOS-1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: UCOS-1 +hex
  c flags: Optim=1 uC99=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER   ARM_MATH_CM4  __CC_ARM
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\FWLIB\inc;..\UCOSII\CONFIG;..\UCOSII\CORE;..\UCOSII\PORT;..\Movecon001\USER;..\Utilities\Third_Party\lwip_v1.3.2\port\STM32F4x7\arch;..\Utilities\Third_Party\lwip_v1.3.2\src\include\netif;..\Utilities\Third_Party\lwip_v1.3.2\src\include;..\Utilities\Third_Party\lwip_v1.3.2\src\include\lwip;..\Utilities\Third_Party\lwip_v1.3.2\port\STM32F4x7;..\Utilities\Third_Party\lwip_v1.3.2\src\include\ipv4;..\Utilities\Third_Party\lwip_v1.3.2\port\STM32F4x7\Standalone;..\Utilities\Third_Party\lwip_v1.3.2\src\api;..\Utilities\Third_Party\lwip_v1.3.2\src\core\ipv4;..\Utilities\Third_Party\lwip_v1.3.2\src\include\ipv4\lwip;..\Utilities\Third_Party\lwip_v1.3.2\src\include\lwip;..\Utilities\Third_Party\lwip_v1.3.2\src\netif\ppp;..\CMSIS\STM32F4x7_ETH_Driver\inc;..\BSP\lwip;..\app\udp;..\Module;..\CMSIS\Driver
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c arm_cortexM4lf_math.lib
  group HARDWARE
    ../HARDWARE/LED/: led.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_fsmc.c stm32f4xx_exti.c stm32f4xx_adc.c stm32f4xx_dac.c stm32f4xx_dma.c stm32f4xx_tim.c stm32f4xx_flash.c
  group UCOSII-CORE
    ../UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOSII-PORT
    ../UCOSII/PORT/: os_cpu_c.c os_cpu_a.asm os_cpu.h
  group UCOSII-CONFIG
    ../UCOSII/CONFIG/: includes.h os_cfg.h
  group README
    ../: readme.txt
  group APP
    ../app/: Sci.c CPUTIMER.C AdcDac.c Pro.c memory.c int_code.c Timer.c IIC.c Ad5933.c
    ../app/udp/: UDPDataUnit.c UdpTask.c UdpTask_Startup.c
  group BSP
    ../BSP/: fsmc.c
    ../BSP/lwip/: UDP_CLIENT.C UDP_SERVER.C netconf.c stm32f4x7_eth_bsp.c NVIC.C
  group LWIP
    ../Utilities/Third_Party/lwip_v1.3.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../Utilities/Third_Party/lwip_v1.3.2/src/core/: dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
    ../Utilities/Third_Party/lwip_v1.3.2/src/netif/: etharp.c loopif.c
    ../Utilities/Third_Party/lwip_v1.3.2/port/STM32F4x7/Standalone/: ethernetif.c
    ../Utilities/Third_Party/lwip_v1.3.2/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../BSP/lwip/: Bsp_Global.c
  group STM32F4x7_ETH_Driver
    ./../CMSIS/STM32F4x7_ETH_Driver/src/: stm32f4x7_eth.c
  group Module
    ../Module/: M_Delay_P.c M_Global.c
